FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " \
           file://0001-RDKTV-35445-Fix-localhost-DNS-resolution.patch \
           "
