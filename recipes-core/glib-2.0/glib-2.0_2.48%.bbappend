SRC_URI_append = " \
           file://log_conntion_failures.patch \
           file://happy_eyeballs_v0.patch \
           file://fix_pollfd_dispatch.patch \
           file://0001-gtlscertificate-Add-ability-to-load-PKCS-12-encrypte_2.48.patch \
           "
