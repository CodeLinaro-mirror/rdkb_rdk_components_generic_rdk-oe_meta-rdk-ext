SRC_URI_append = " \
           file://0001-Fix-passing-NULL-to-g_task_get_cancellable.patch \
           "
