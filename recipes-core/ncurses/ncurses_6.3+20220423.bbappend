FILESEXTRAPATHS_append := "${THISDIR}/files:"

SRC_URI_append = "file://CVE-2023-29491_6.3_fix.patch "
