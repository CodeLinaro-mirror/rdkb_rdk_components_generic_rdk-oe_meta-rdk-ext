PROVIDES += "glib-openssl"
RPROVIDES_${PN} += "glib-openssl"