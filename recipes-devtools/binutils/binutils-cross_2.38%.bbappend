FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://CVE-2023-1972_2.38_fix.patch"

