FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://CVE-2023-32732_1.45_fix.patch"

