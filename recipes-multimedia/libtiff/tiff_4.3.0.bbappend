FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://CVE-2023-40745_4.3.0_fix.patch \
            file://CVE-2023-52356_4.3.0_fix.patch \
            file://CVE-2022-3627_4.3.0_fix.patch \
            file://CVE-2023-6277_4.3.0_fix.patch \
            file://CVE-2023-41175_4.3.0_fix.patch \
            file://CVE-2023-3618_4.3.0_fix.patch \
            file://CVE-2024-7006_4.3.0_fix.patch \
            file://CVE-2023-3316_4.3.0_fix.patch \
            file://CVE-2022-3970_4.3.0_fix.patch \
            file://CVE-2022-40090_4.3.0_fix.patch \
            file://CVE-2022-3598_4.3.0_fix.patch \
            file://CVE-2022-3599_4.3.0_fix.patch \
            "
