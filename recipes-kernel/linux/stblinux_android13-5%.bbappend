stblinux_android-5%.bbappend